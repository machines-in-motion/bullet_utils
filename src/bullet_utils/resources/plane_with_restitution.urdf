Commit message: added bulletenv

File: src/bullet_utils/resources/plane_with_restitution.urdf (robot description, URDF)
Before this commit: robot plane, 1 links, 0 joints
Links:
- link planeLink: geometry collision box size=30 30 10; visual mesh filename=package://meshes/plane.obj scale=1 1 1
